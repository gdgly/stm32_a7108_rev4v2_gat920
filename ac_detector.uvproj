# Keil uVision project ac_detector.uvproj, settings and files
target RFrelay (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RF STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x8000000-0x80BFFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32_a7108_rev4v2_gat920 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .\Hardware\a7108;.\Hardware\driver;.\Hardware\modbus;.\Hardware\nrf24l01;.\Libraries\library2008\inc;.\User;.\Hardware\rtc;.\Hardware\usart;.\Hardware\gat920;.\Hardware\tcpsocket;.\Hardware\extendsocket;.\Hardware\modulationsocket;.\Hardware\xunfeisocket;.\Hardware\calculation;.\Hardware\iooutput;.\Hardware\usr;.\Hardware\lestc;.\Hardware\FifoMessage
  memory RVCT4: ROM 0x8000000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Start Code
    ./: cortexm3_macro.s stm32f10x_vector.s
  group LIB
    ./Libraries/library2008/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ./Hardware/a7108/: a7108.c
    ./Hardware/nrf24l01/: NRF24L01.C
    ./Hardware/usart/: bsp_usart.c
  group USER
    ./User/: main.c SetClock.c SetNVIC.c stm32_config.c stm32f10x_it.c platform_config.c platform_config.h define.h
  group modbus
    ./Hardware/modbus/: mb.c mbcrc.c mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbrtu.c mbutils.c
  group driver
    ./Hardware/driver/: portevent.c portserial.c porttimer.c
  group iooutput
    ./Hardware/iooutput/: iooutputconfig.c iooutputfunc.c
  group gat920
    ./Hardware/gat920/: gatconfig.c gatfunc.c gatconnect.c gatserial.c gatupload.c
  group FifoMessage
    ./Hardware/FifoMessage/: fifomessage.c
  group socket
    ./Hardware/tcpsocket/: socketconfig.c socketinitialization.c socketfunc.c socketinstantia.c socketpark.c
  group socketextend
    ./Hardware/extendsocket/: socketextendconfig.c socketextendinitialization.c socketextendfunc.c socketextendinstantia.c
  group socketmodulation
    ./Hardware/modulationsocket/: socketmodulationconfig.c socketmodulationinitialization.c socketmodulationfunc.c socketmodulationinstantia.c
  group socketxunfei
    ./Hardware/xunfeisocket/: socketxunfeiconfig.c socketxunfeiinitialization.c socketxunfeifunc.c socketxunfeiinstantia.c socketxunfeimessage.c sock.c
  group calculation
    ./Hardware/calculation/: calculationconfig.c calculationvolume.c calculationavgspeed.c calculationavgoccupancy.c calculationavgheadtime.c
  group rtc
    ./Hardware/rtc/: rtc.c rtc_date.c
  group usr
    ./Hardware/usr/: usrconfig.c usrserial.c usrgprs.c usrK2.c
  group lestc
    ./Hardware/lestc/: lestcconfig.c lestcfunc.c
  group ReadMe
    ./: Readme.md
